# Keil uVision project IPA_Messstation.uvprojx, settings and files
target IPA_Messstation (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: IPA_Messstation +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x6
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
--debug
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_uart.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c
  group Application/User
    ../Src/: stm32f0xx_hal_msp.c stm32f0xx_it.c main.c I2C.c Init.c UART.c RC1740HP.c SHT31.c
software components: CMSIS:CORE 4.1.0
